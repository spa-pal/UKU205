# Keil uVision project UKU205.uvproj, settings and files
target MK (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU205 +hex
  c flags: Optim=4
  c define: UKU_VERSION=900
  c include: ..\common\inc;C:\Keil\ARM\INC\NXP\LPC17xx
  asm include: ..\common\inc;C:\Keil\ARM\INC\NXP\LPC17xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s Net_Config_HTTP.c
  group Core Code
    ./: core_cm3.c
  group System Code
    ./: system_LPC17xx.c
  group Sources
    ./: main.c control.c avar.c common_func.c simbols.c gran.c graphic.c ret.c eeprom_map.c memo.c
  group Target
    ./: beep.c 25lc640.c lcd_agm1232_uku203.c
  group Interfaces
    ./: full_can.c uart2.c uart0.c snmp_data_file.c SNMP_MIB.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    ./Web/: Web.c
target MK24 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_mk24 +hex
  c flags: Optim=1
  c define: UKU_VERSION=900, _24_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MS (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MS +hex
  c flags: Optim=1
  c define: UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MS24 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MS24 +hex
  c flags: Optim=1
  c define: UKU_VERSION=300, _24_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MS_RELEASE (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MS +hex
  AfterMake: ms.bat
  c flags: Optim=1
  c define: UKU_VERSION=300
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MK_RELEASE (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MK +hex
  AfterMake: E:\Users\Pal\DEVICES\UKU202.03\SOFT\1\mk.bat
  c flags: Optim=1
  c define: UKU_VERSION=900
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MK24_RELEASE (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1 +hex
  c flags: Optim=1
  c define: UKU_VERSION=900, _24_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target MS24_RELEASE (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MS24 +hex
  c flags: Optim=1
  c define: UKU_VERSION=300, _24_
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target 1U_COMM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UKU20203_1_MK +hex
  c flags: Optim=1
  c define: UKU_VERSION=900
  c include: ..\common\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
